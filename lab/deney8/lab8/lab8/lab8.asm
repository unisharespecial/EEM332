LIST P=16F84A
INCLUDE P16F84A.INC
C1 EQU 0x0C
C2 EQU 0x0D

BSF STATUS,5
MOVLW B'00000001'
MOVWF TRISA
CLRF TRISB

BCF STATUS,5
CLRF PORTB

BASLA
MOVLW B'01010101'
MOVWF PORTB

BUTTON

BTFSS PORTA,0

GOTO BASLA
MOVLW B'10101010'
MOVWF PORTB

CALL DELAY
CALL DELAY
CALL DELAY
CALL DELAY
CALL DELAY

CALL DELAY
CALL DELAY
CALL DELAY
CALL DELAY
CALL DELAY

CALL DELAY
CALL DELAY
CALL DELAY
CALL DELAY

GOTO BUTTON 

DELAY

MOVLW .255
MOVWF C2
D2
	MOVLW .255
	MOVWF C1
 D1 
 DECFSZ C1,f
 GOTO D1
DECFSZ C2,f
GOTO D2

RETURN

END